# Keil uVision project TIM_LED_blink_PWM_PB7.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20020000,0x0005C000) IROM(0x08000000,0x00200000) IROM2(0x00200000,0x00200000) XRAM(0x2007C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TIM_LED_blink_PWM
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT6: RAM 0x2007c000 size 0x4000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x5c000
  group Source Group 1
    ./: main.c main.h stm32f767xx_GPIO.h stm32f767xx_TIM.h stm32f767xx_RCC.h stm32f767xx_it.h stm32f767xx_it.c stm32f767xx_GPIO.c stm32f767xx_TIM.c stm32f767xx_RCC.c
software components: CMSIS:CORE 6.0.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.2.5
